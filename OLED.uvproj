# Keil uVision project OLED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: OLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\lib\delay;.\lib\OLED;.\lib\led;.\lib\key;.\lib\DS1302;.\lib\usart;.\lib\DHT11;.\lib\timer;.\lib\gui;.\lib\buzzer
  group Source Group 1
    ./: main.c
    ./lib/delay/: delay.c
    ./lib/led/: led.c
    ./lib/DHT11/: DHT11.C
    ./lib/DS1302/: ds1302.c
    ./lib/key/: key.c
    ./lib/OLED/: oled.c oledfont.c
    ./lib/usart/: usart.c
    ./lib/timer/: timer.c
    ./lib/gui/: gui.c dlg_desktop.c dlg_KeyDemo.c dlg_LedDemo.c dlg_mainmenu.c dlg_RTCDemo.c dlg_DHTDemo.c dlg_BuzzerTDemo.c
    ./lib/buzzer/: buzzer.c
